# Keil uVision project CMSIS_RTOS2.uvprojx, settings and files
target Release (6190000::V6.19::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: cmsis_rtos2 (library)
  AfterMake: xcopy /Y .\Objects\cmsis_rtos2.lib ..\
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: RTE_COMPONENTS_H=" ", CMSIS_device_header="<M55M1.h>"
  c include: ..\..\..\Core\Include;..\..\..\..\Device\Nuvoton\M55M1\Include;..\..\..\..\StdDriver\inc;..\..\..\RTOS2\Include
  asm include: ..\..\..\RTX\Include;..\..\..\RTX\Config
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Source
    ../../../RTOS2/Source/: os_systick.c
