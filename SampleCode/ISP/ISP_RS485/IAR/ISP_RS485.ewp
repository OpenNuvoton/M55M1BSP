# IAR project ISP_RS485.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ISP_RS485.bin
  ILINK.IlinkOutputFile: ISP_RS485.out
  ILINK.IlinkIcfFile: ..\..\..\..\Library\Device\Nuvoton\M55M1\Source\IAR\M55M1-LDROM.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../common/: ISP_startup_M55M1.c ISP_system_M55M1.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../../common/: fmc_user.c isp_user.c targetdev.c
    ../: main.c uart_transfer.c
