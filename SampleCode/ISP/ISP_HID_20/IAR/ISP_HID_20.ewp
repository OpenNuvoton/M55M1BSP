# IAR project ISP_HID_20.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ISP_HID_20.bin
  ILINK.IlinkOutputFile: ISP_HID_20.out
  ILINK.IlinkIcfFile: ..\..\..\..\Library\Device\Nuvoton\M55M1\Source\IAR\M55M1-LDROM.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../common/: ISP_startup_M55M1.c ISP_system_M55M1.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c hsusbd.c sys.c
  group User
    ../: descriptors.c hid_transfer.c main.c
    ../../common/: fmc_user.c isp_user.c targetdev.c
