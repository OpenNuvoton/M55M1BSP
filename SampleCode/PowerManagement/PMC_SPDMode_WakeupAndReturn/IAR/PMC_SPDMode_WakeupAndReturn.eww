<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\PMC_SPDMode_WakeupAndReturn.ewp</path>
    </project>
    <batchBuild />
</workspace>
