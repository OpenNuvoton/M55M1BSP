# Keil uVision project MP3_Recorder.uvprojx, settings and files
target MP3_Recorder (6190000::V6.19::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.25
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: MP3_Recorder
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: __WINS__ OPT_SPEED
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Storage;..\..\..\..\ThirdParty\FatFs\source;..\..\..\..\ThirdParty\libmad\inc;..\..\..\..\ThirdParty\shine\src\lib;..\..\MP3_Recorder
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\M55M1.scatter
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c gpio.c i2s.c i2c.c pdma.c sdh.c spim_hyper.c
  group FATFS
    ../../../../ThirdParty/FATFS/source/: ff.c
  group MP3Lib
    ../../../../ThirdParty/libmad/src/: version.c bit.c decoder.c fixed.c frame.c huffman.c layer3.c layer12.c MP3Func.c stream.c synth.c timer.c
  group Source
    ../: main.c sdglue.c mp3.c mp3headerparser.c isr.c audio_codec.c mp3recorder.c hyperram_code.c
    ../../../../Library/Storage/: diskio_SDH.c
  group SHINE
    ../../../../ThirdParty/shine/src/lib/: bitstream.c huffm.c l3.c l3bitstream.c l3loop.c l3mdct.c l3subband.c reservoir.c tables.c
