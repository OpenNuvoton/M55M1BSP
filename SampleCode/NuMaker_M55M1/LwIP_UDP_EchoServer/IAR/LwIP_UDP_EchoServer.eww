<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LwIP_UDP_EchoServer.ewp</path>
    </project>
    <batchBuild />
</workspace>
