# IAR project ACI_SinCos.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG
  ICCARM.IExtraOptions: --cdecp=2 --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\CMSIS\DSP\Include; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ACI_SinCos.bin
  ILINK.IlinkOutputFile: ACI_SinCos.out
  ILINK.IlinkIcfFile: ..\..\..\..\Library\Device\Nuvoton\M55M1\Source\IAR\M55M1.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../: ACI_SinCos.c main.c
