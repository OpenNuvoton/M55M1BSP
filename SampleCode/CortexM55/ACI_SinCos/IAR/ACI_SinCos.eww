<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ACI_SinCos.ewp</path>
    </project>
    <batchBuild />
</workspace>
