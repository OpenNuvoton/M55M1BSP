<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MPU_Memory_AccessPermission.ewp</path>
    </project>
    <batchBuild />
</workspace>
