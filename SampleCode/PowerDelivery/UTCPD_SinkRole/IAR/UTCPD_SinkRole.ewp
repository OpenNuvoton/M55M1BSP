# IAR project UTCPD_SinkRole.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG; USING_UART0=1; OPT_SRC_ONLY=0; OPT_SNK_ONLY=1; E_VBUS_DIVIDER=10
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\PowerDeliveryLib\Include; ..\..\..\..\Library\PowerDeliveryLib\Include\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UTCPD_SinkRole.bin
  ILINK.IlinkOutputFile: UTCPD_SinkRole.out
  ILINK.IlinkIcfFile: ..\..\..\..\Library\Device\Nuvoton\M55M1\Source\IAR\M55M1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Driver
    ../../../../Library/StdDriver/src/: acmp.c clk.c eadc.c gpio.c retarget.c sys.c timer.c uart.c utcpd.c
  group Library
    ../../../../Library/PowerDeliveryLib/: PD_SNK.a
  group User
    ../: commandshell.c ec_adc.c main.c usb_MultipleFunction.c usb_pd_policy.c usb_powerctrl.c
