<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\UTCPD_SourceRole.ewp</path>
    </project>
    <batchBuild />
</workspace>
