# IAR project XOMLibDemo.ewp, settings and files
configuration Bank0 (ARM)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG; DL_BANK=0
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\XOMLib\lib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: XOMLibDemo.bin
  ILINK.IlinkOutputFile: XOMLibDemo.out
  ILINK.IlinkIcfFile: XOMLibDemo.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Bank1 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; DL_BANK=1
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
    ../../XOMLib/lib/: XOMLib.a
  group User
    ../: main.c
