# IAR project Jpeg_Display.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG; TEST_GRAYSCALE=0; WITH_JPEGACC; _PANEL_DISPLAY_320X240
  ICCARM.CCDiagSuppress: Pa089, Pe177, Pe188, Pa082
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\CMSIS\DSP\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\Storage; ..\..\..\..\ThirdParty\FatFs\source; ..\..\..\..\Library\JpegAcceleratorLib\include; ..\..\..\..\ThirdParty\libjpeg; ..\..\..\..\ThirdParty\openmv\omv\imlib; ..\..\..\..\ThirdParty\openmv\omv\alloc; ..\..\..\..\ThirdParty\openmv\omv\common; ..\..\..\..\ThirdParty\openmv\omv\Lib; ..\..\..\..\ThirdParty\openmv\omv; ..\Device\Display\LCD; ..\Device\include; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Jpeg_Display.bin
  ILINK.IlinkOutputFile: Jpeg_Display.out
  ILINK.IlinkIcfFile: M55M1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Device
    ../Device/Display/: Display.c drv_pdma.c Font8_16.c
    ../Device/Display/LCD/: LCD_LT7381.c
  group FATFS
    ../../../../ThirdParty/FatFs/source/: ff.c
  group Lib
    ../../../../Library/JpegAcceleratorLib/: JpegAcceleratorLib.a
    ../../../../ThirdParty/openmv/omv/Lib/: omv.a
  group libjpeg
    ../../../../ThirdParty/libjpeg/: jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatadst.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jmemansi.c jmemmgr.c jquant1.c jquant2.c jutils.c rdbmp.c rdcolmap.c rdgif.c rdppm.c rdrle.c rdswitch.c rdtarga.c transupp.c wrbmp.c wrgif.c wrppm.c wrrle.c wrtarga.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c ebi.c epwm.c gpio.c i2c.c pdma.c retarget.c sdh.c sys.c timer.c uart.c
  group User
    ../../../../Library/Storage/: diskio_SDH.c
    ../: jpeg.c main.c SDGlue.c
