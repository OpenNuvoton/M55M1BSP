<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Jpeg_Display.ewp</path>
    </project>
    <batchBuild />
</workspace>
