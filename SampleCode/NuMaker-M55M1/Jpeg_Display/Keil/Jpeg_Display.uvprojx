# Keil uVision project Jpeg_Display.uvprojx, settings and files
target Jpeg_Display (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: Jpeg_Display
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: TEST_GRAYSCALE=0 ,WITH_JPEGACC, _PANEL_DISPLAY_320X240
  c misc: -Wno-unused-parameter -Wno-unused-variable -Wno-char-subscripts -Wconditional-uninitialized
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\CMSIS\DSP\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Storage;..\..\..\..\ThirdParty\FatFs\source;..\..\..\..\Library\JpegAcceleratorLib\include;..\..\..\..\ThirdParty\libjpeg;..\..\..\..\ThirdParty\openmv\omv\imlib;..\..\..\..\ThirdParty\openmv\omv\alloc;..\..\..\..\ThirdParty\openmv\omv\common;..\..\..\..\ThirdParty\openmv\omv\Lib;..\..\..\..\ThirdParty\openmv\omv;..\Device\Display\LCD;..\Device\include;..
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\M55M1.scf
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c gpio.c sdh.c timer.c pdma.c ebi.c epwm.c i2c.c
  group User
    ../: main.c SDGlue.c jpeg.c
    ../../../../Library/Storage/: diskio_SDH.c
  group FATFS
    ../../../../ThirdParty/FatFs/source/: ff.c
  group libjpeg
    ../../../../ThirdParty/libjpeg/: jdapimin.c jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jctrans.c jdapistd.c jdarith.c jdatadst.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jmemansi.c jmemmgr.c jquant1.c jquant2.c jutils.c rdbmp.c rdcolmap.c rdgif.c rdppm.c rdrle.c rdswitch.c rdtarga.c transupp.c wrbmp.c wrgif.c wrppm.c wrrle.c wrtarga.c
  group JpegAccelerator
    ../../../../Library/JpegAcceleratorLib/: JpegAcceleratorLib_Keil.lib
  group omvLib
    ../../../../ThirdParty/openmv/omv/Lib/: omv.lib
  group Device
    ../Device/Display/: Display.c drv_pdma.c Font8_16.c
    ../Device/Display/LCD/: LCD_LT7381.c
