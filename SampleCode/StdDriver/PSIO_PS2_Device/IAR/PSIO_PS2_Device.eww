<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\PSIO_PS2_Device.ewp</path>
    </project>
    <batchBuild />
</workspace>
