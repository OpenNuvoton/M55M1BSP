<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SPII2S_PDMA_PlayRecord.ewp</path>
    </project>
    <batchBuild />
</workspace>
