<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\EPWM_PDMA_Capture.ewp</path>
    </project>
    <batchBuild />
</workspace>
