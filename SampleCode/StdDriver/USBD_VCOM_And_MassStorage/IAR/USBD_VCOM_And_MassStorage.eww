<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\USBD_VCOM_And_MassStorage.ewp</path>
    </project>
    <batchBuild />
</workspace>
