<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\I2S_Codec_PDMA.ewp</path>
    </project>
    <batchBuild />
</workspace>
