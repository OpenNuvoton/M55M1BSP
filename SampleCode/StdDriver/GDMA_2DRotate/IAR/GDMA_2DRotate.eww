<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\GDMA_2DRotate.ewp</path>
    </project>
    <batchBuild />
</workspace>
