<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\GDMA_TemplateTransfer.ewp</path>
    </project>
    <batchBuild />
</workspace>
