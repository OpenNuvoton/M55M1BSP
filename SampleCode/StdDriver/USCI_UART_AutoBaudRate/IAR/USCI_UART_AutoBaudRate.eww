<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\USCI_UART_AutoBaudRate.ewp</path>
    </project>
    <batchBuild />
</workspace>
