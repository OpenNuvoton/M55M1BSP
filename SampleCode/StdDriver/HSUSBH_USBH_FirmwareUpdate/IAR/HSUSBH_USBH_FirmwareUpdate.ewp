# IAR project HSUSBH_USBH_FirmwareUpdate.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDiagSuppress: Pa082,Pe177
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\UsbHostLib\inc; ..\..\..\..\Library\UsbHostLib\src_core; ..\..\..\..\Library\UsbHostLib\src_msc; ..\..\..\..\ThirdParty\FatFs\source
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: HSUSBH_USBH_FirmwareUpdate.bin
  ILINK.IlinkOutputFile: HSUSBH_USBH_FirmwareUpdate.out
  ILINK.IlinkIcfFile: M55M1_FirmwareUpdate.icf
  ILINK.IlinkExtraOptions: --redirect __write=__write_own
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\UsbHostLib\inc; ..\..\..\..\Library\UsbHostLib\src_core; ..\..\..\..\Library\UsbHostLib\src_msc; ..\..\..\..\ThirdParty\FatFs\source
  ICCARM.IccLang: 0
  ILINK.IlinkExtraOptions: ielftool --bin-multi
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Driver
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group ThirdParty_FatFs
    ../../../../ThirdParty/FatFs/source/: ff.c
  group UsbHostLib
    ../../../../Library/UsbHostLib/src_core/: ehci.c ehci_iso.c hub.c mem_alloc.c ohci_0.c ohci_1.c usb_core.c
  group UsbHostLib_MSC
    ../../../../Library/UsbHostLib/src_msc/: msc_driver.c msc_xfer.c
  group User
    ../../../../Library/Storage/: diskio_USBHost.c
    ../: main.c usbh_update.c
