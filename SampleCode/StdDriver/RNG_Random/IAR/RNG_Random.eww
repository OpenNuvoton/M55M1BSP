<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\RNG_Random.ewp</path>
    </project>
    <batchBuild />
</workspace>
