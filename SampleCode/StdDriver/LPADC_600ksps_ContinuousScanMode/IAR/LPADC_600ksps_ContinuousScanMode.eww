<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LPADC_600ksps_ContinuousScanMode.ewp</path>
    </project>
    <batchBuild />
</workspace>
