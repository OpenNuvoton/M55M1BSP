<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LPPDMA_ScatterGather_PingPongBuffer.ewp</path>
    </project>
    <batchBuild />
</workspace>
