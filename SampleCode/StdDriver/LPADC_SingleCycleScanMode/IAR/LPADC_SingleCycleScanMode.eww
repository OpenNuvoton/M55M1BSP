<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LPADC_SingleCycleScanMode.ewp</path>
    </project>
    <batchBuild />
</workspace>
