<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\CANFD_CAN_Loopback.ewp</path>
    </project>
    <batchBuild />
</workspace>
