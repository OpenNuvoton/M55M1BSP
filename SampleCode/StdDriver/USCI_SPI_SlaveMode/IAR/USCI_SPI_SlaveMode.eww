<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\USCI_SPI_SlaveMode.ewp</path>
    </project>
    <batchBuild />
</workspace>
