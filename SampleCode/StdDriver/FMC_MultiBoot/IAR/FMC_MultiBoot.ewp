# IAR project FMC_MultiBoot.ewp, settings and files
configuration FMC_MultiBoot_0x100000 (ARM)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FMC_MultiBoot_0x100000.bin
  ILINK.IlinkOutputFile: FMC_MultiBoot_0x100000.out
  ILINK.IlinkConfigDefines: VECMAP_BASE=0x100000
  ILINK.IlinkIcfFile: FMC_MultiBoot_APROM.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration FMC_MultiBoot_0x160000 (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: FMC_MultiBoot_0x160000.bin
  ILINK.IlinkOutputFile: FMC_MultiBoot_0x160000.out
  ILINK.IlinkConfigDefines: VECMAP_BASE=0x160000
configuration FMC_MultiBoot_0x1C0000 (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: FMC_MultiBoot_0x1C0000.bin
  ILINK.IlinkOutputFile: FMC_MultiBoot_0x1C0000.out
  ILINK.IlinkConfigDefines: VECMAP_BASE=0x1C0000
configuration FMC_MultiBoot_0x220000 (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: FMC_MultiBoot_0x220000.bin
  ILINK.IlinkOutputFile: FMC_MultiBoot_0x220000.out
  ILINK.IlinkConfigDefines: VECMAP_BASE=0x220000
configuration FMC_MultiBoot_0x280000 (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: FMC_MultiBoot_0x280000.bin
  ILINK.IlinkOutputFile: FMC_MultiBoot_0x280000.out
  ILINK.IlinkConfigDefines: VECMAP_BASE=0x280000
configuration FMC_MultiBoot_LDROM (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __LDROM__
  OBJCOPY.OOCOutputFile: FMC_MultiBoot_LDROM.bin
  ILINK.IlinkOutputFile: FMC_MultiBoot_LDROM.out
  ILINK.IlinkIcfFile: ..\..\..\..\Library\Device\Nuvoton\M55M1\Source\IAR\M55M1-LDROM.icf
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group User
    ../: main.c
