<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\CCAP_Packet_JpegEncode.ewp</path>
    </project>
    <batchBuild />
</workspace>
