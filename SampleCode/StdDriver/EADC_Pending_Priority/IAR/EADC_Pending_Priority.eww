<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\EADC_Pending_Priority.ewp</path>
    </project>
    <batchBuild />
</workspace>
