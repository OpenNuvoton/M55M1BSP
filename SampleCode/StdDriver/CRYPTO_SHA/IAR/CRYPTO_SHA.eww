<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\CRYPTO_SHA.ewp</path>
    </project>
    <batchBuild />
</workspace>
