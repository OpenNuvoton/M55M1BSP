<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\KS_ECDH.ewp</path>
    </project>
    <batchBuild />
</workspace>
