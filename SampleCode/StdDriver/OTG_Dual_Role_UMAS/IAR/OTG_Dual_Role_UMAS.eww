<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\OTG_Dual_Role_UMAS.ewp</path>
    </project>
    <batchBuild />
</workspace>
