<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\HSUSBH_USBH_VENDOR_LBK.ewp</path>
    </project>
    <batchBuild />
</workspace>
