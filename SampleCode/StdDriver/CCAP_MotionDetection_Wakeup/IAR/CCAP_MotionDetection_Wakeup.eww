<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\CCAP_MotionDetection_Wakeup.ewp</path>
    </project>
    <batchBuild />
</workspace>
