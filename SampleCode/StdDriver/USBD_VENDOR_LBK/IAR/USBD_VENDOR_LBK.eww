<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\USBD_VENDOR_LBK.ewp</path>
    </project>
    <batchBuild />
</workspace>
