# IAR project HSUSBD_Audio10_Headset.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HSUSBD_Audio10_Headset.bin
  ILINK.IlinkOutputFile: HSUSBD_Audio10_Headset.out
  ILINK.IlinkIcfFile: ..\..\..\..\Library\Device\Nuvoton\M55M1\Source\IAR\M55M1.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Driver
    ../../../../Library/StdDriver/src/: clk.c gpio.c hsusbd.c i2c.c i2s.c pdma.c retarget.c sys.c timer.c uart.c
  group User
    ../: audio_codec.c config_pdma.c descriptors.c hid.c main.c resample.c usbd_audio.c
