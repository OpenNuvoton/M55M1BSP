<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\EADC_PDMA_EPWM_Trigger.ewp</path>
    </project>
    <batchBuild />
</workspace>
