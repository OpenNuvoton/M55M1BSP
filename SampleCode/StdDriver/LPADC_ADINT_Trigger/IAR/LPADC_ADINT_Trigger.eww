<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LPADC_ADINT_Trigger.ewp</path>
    </project>
    <batchBuild />
</workspace>
