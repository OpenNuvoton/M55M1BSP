<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\CRYPTO_RSA_CRTBypass.ewp</path>
    </project>
    <batchBuild />
</workspace>
