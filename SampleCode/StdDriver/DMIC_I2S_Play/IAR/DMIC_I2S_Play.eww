<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\DMIC_I2S_Play.ewp</path>
    </project>
    <batchBuild />
</workspace>
