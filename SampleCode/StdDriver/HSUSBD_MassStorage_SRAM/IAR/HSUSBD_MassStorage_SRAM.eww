<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\HSUSBD_MassStorage_SRAM.ewp</path>
    </project>
    <batchBuild />
</workspace>
