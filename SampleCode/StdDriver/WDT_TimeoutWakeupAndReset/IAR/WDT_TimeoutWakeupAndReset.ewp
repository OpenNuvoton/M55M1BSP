# IAR project WDT_TimeoutWakeupAndReset.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\CMSIS\Core\Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: WDT_TimeoutWakeupAndReset.bin
  ILINK.IlinkOutputFile: WDT_TimeoutWakeupAndReset.out
  ILINK.IlinkIcfFile: ..\..\..\..\Library\Device\Nuvoton\M55M1\Source\IAR\M55M1.icf
  ILINK.IlinkExtraOptions: --redirect __write=__write_own
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Driver
    ../../../../Library/StdDriver/src/: clk.c gpio.c pmc.c retarget.c sys.c uart.c wdt.c
  group User
    ../: main.c
