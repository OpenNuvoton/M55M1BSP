<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SPIM_DMM_RUN_CODE.ewp</path>
    </project>
    <batchBuild />
</workspace>
