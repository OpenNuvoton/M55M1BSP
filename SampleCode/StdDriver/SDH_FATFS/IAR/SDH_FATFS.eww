<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SDH_FATFS.ewp</path>
    </project>
    <batchBuild />
</workspace>
