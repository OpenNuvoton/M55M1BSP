<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\NPU_Conv.ewp</path>
    </project>
    <batchBuild />
</workspace>
