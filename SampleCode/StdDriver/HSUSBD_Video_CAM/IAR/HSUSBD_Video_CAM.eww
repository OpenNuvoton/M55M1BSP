<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\HSUSBD_Video_CAM.ewp</path>
    </project>
    <batchBuild />
</workspace>
