<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\USBD_MassStorage_SD.ewp</path>
    </project>
    <batchBuild />
</workspace>
