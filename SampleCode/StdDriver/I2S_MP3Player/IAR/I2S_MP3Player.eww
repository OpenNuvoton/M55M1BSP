<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\I2S_MP3Player.ewp</path>
    </project>
    <batchBuild />
</workspace>
