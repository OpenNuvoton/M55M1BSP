<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\I2C_Double_Buffer_Slave.ewp</path>
    </project>
    <batchBuild />
</workspace>
