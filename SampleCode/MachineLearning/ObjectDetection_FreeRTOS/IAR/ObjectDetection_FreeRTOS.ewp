# IAR project ObjectDetection_FreeRTOS.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NVT_VECTOR_ON_FLASH; TF_LITE_STATIC_MEMORY; ARM_MATH_DSP; ARM_NPU; ACTIVATION_BUF_SZ=0x00130000
  ICCARM.CCDiagSuppress: Pe550, Pe997, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\CMSIS\DSP\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\StdDriver\inc\npu; ..\..\..\..\ThirdParty\openmv\omv\imlib; ..\..\..\..\ThirdParty\openmv\omv\alloc; ..\..\..\..\ThirdParty\openmv\omv\common; ..\..\..\..\ThirdParty\openmv\omv\Lib; ..\..\..\..\ThirdParty\tflite_micro; ..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-flatbuffers-src\include; ..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\api\common\include; ..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\log\include; ..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\math\include; ..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\main\include; ..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\profiler\include; ..\Device\include; ..\Model\include; ..\NPU\include; ..\Pattern\include; ..\ProfilerCounter\include; ..\..\..\..\ThirdParty\FreeRTOS\Source\include; ..\..\..\..\ThirdParty\FreeRTOS\Lib; ..\..\..\..\ThirdParty\FreeRTOS\Source\portable\IAR\ARM_CM55_NTZ\non_secure; ..; ..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-gemlowp-src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: ObjectDetection_FreeRTOS.srec
  ILINK.IlinkOutputFile: ObjectDetection_FreeRTOS.out
  ILINK.IlinkIcfFile: M55M1.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Application
    ../: BoardInit.cpp DetectorPostProcessing.cpp InferenceTask.cpp main.cpp
  group ArmMLApi
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/application/api/common/source/: Classifier.cc ImageUtils.cc Model.cc TensorFlowLiteMicro.cc
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/math/: PlatformMath.cc
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/profiler/: Profiler.cc
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Device
    ../Device/UVC/: descriptors.c UVC.c
    ../Device/Display/: Display.c drv_pdma.c Font8_16.c
    ../Device/HyperRAM/: hyperram_code.c
    ../Device/ImageSensor/: ImageSensor.c
    ../Device/Display/LCD/: LCD_FSA506.c LCD_ILI9341.c LCD_LT7381.c
    ../Device/ImageSensor/Sensor/: Sensor_HM1055.c SWI2C.c
  group Driver
    ../../../../Library/StdDriver/src/: ccap.c clk.c ebi.c gpio.c hsusbd.c pdma.c retarget.c spi.c spim_hyper.c sys.c uart.c
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group Lib
    ../../../../Library/CMSIS/Lib/IAR/: CMSIS_DSP.a CMSIS_NN.a
    ../../../../ThirdParty/FreeRTOS/Lib/: FreeRTOS.a
    ../../../../ThirdParty/openmv/omv/Lib/: omv.a
    ../../../../ThirdParty/tflite_micro/Lib/: tflu.a
  group Model
    ../Model/: Labels.cpp yolo-fastest_int8_vela_H256.tflite.cpp YoloFastestModel.cpp
  group NPU
    ../NPU/: ethosu_cpu_cache.c ethosu_npu_init.c ethosu_profiler.c
  group Pattern
    ../Pattern/: car.cpp dinner.cpp InputFiles.cpp
  group ProfilerCounter
    ../ProfilerCounter/: pmu_counter.c
