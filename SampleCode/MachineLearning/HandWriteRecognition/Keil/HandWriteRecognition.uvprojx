# Keil uVision project HandWriteRecognition.uvprojx, settings and files
target HandWriteRecognition (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.2
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: HandWriteRecognition
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: ARM_MATH_DSP,ARM_MATH_HELIUM,TF_LITE_STATIC_MEMORY,CMSIS_NN, ARM_NPU
  c misc: -Wconditional-uninitialized
  c include: ..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\inc\npu;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\CMSIS\NN\Include;..\..\..\..\Library\CMSIS\DSP\Include;..\..\..\..\ThirdParty\tflite_micro;..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-flatbuffers-src\include;..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-gemlowp-src;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\api\common\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\main\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\log\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\math\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\profiler\include;..\NN\CNN\;..\NNClassify\;..\NPU\include;..\Generated\;..\NN\;..\;..\ImageProcess\Inc;..\Device\include;..\..\..\..\ThirdParty\openmv\omv\imlib;..\..\..\..\ThirdParty\openmv\omv\common;..\..\..\..\ThirdParty\openmv\omv\alloc;..\..\..\..\ThirdParty\openmv\omv\Lib;..\ili9341\
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M55M1\Source\ARM\M55M1.scf
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Generated
    ../Generated/: MNIST_fdmobilenet_wd4_corrupted_vela.tflite.cpp
  group Library
    ../../../../ThirdParty/tflite_micro/Lib/: tflu.lib
    ../../../../Library/CMSIS/Lib/Keil/: cmsis_dsp.lib cmsis_nn.lib
    ../../../../ThirdParty/openmv/omv/Lib/: omv.lib
  group Classify
    ../NNClassify/: MainClassify.cpp
  group NN
    ../NN/: Model.cpp
    ../NN/CNN/: CnnModel.cpp
  group NPU
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group Driver
    ../../../../Library/StdDriver/src/: retarget.c uart.c clk.c sys.c gpio.c epwm.c timer.c ebi.c i2c.c
    ../NPU/: ethosu_npu_init.c ethosu_profiler.c ethosu_cpu_cache.c
  group Device
    ../Device/Display/: fsa506.c st1633i.c
  group ImageProcess
    ../ImageProcess/Src/: ImgConvert.c
  group User
    ../: main.cpp mpu_config_M55M1.h
  group ILI9341
    ../ili9341/: fonts.c
