# IAR project HandWriteRecognition.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NVT_VECTOR_ON_FLASH; TF_LITE_STATIC_MEMORY; ARM_MATH_DSP; ARM_NPU; ACTIVATION_BUF_SZ=0x14000
  ICCARM.CCDiagSuppress: Pe550, Pe997
  ICCARM.IExtraOptions: --diag_suppress Pe550; --diag_suppress Pe177; --diag_suppress Pe111
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\CMSIS\DSP\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\StdDriver\inc\npu; ..\..\..\..\ThirdParty\openmv\omv\imlib; ..\..\..\..\ThirdParty\openmv\omv\alloc; ..\..\..\..\ThirdParty\openmv\omv\common; ..\..\..\..\ThirdParty\openmv\omv\Lib; ..\..\..\..\ThirdParty\tflite_micro; ..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-flatbuffers-src\include; ..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\api\common\include; ..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\log\include; ..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\math\include; ..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\main\include; ..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\profiler\include; ..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\api\use_case\kws\include; ..\Device\include; ..\ImageProcess\Inc; ..\ili9341; ..\Generated; ..\NNClassify; ..\NPU\include; ..\NN\CNN; ..\NN; ..; ..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-gemlowp-src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: HandWriteRecognition.srec
  ILINK.IlinkOutputFile: HandWriteRecognition.out
  ILINK.IlinkIcfFile: M55M1.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Application
    ../: main.cpp mpu_config_M55M1.h
  group Classify
    ../NNClassify/: MainClassify.cpp
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Device
    ../ili9341/: fonts.c
    ../Device/Display/: fsa506.c st1633i.c
  group Driver
    ../../../../Library/StdDriver/src/: clk.c ebi.c epwm.c gpio.c i2c.c retarget.c sys.c timer.c uart.c
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group ImageProcess
    ../ImageProcess/Src/: ImgConvert.c
  group Lib
    ../../../../Library/CMSIS/Lib/IAR/: CMSIS_DSP.a CMSIS_NN.a
    ../../../../ThirdParty/openmv/omv/Lib/: omv.a
    ../../../../ThirdParty/tflite_micro/Lib/: tflu.a
  group Model
    ../Generated/: MNIST_fdmobilenet_wd4_corrupted_vela.tflite.cpp numbering_10.c
  group NN
    ../NN/CNN/: CnnModel.cpp
    ../NN/: Model.cpp
  group NPU
    ../NPU/: ethosu_cpu_cache.c ethosu_npu_init.c ethosu_profiler.c
