# Keil uVision project VisualWakeWords_ModelProtect_TVM.uvprojx, settings and files
target VisualWakeWords_ModelProtect_TVM (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.2
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: VisualWakeWords_ModelProtect_TVM
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\release\@L.bin"
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: NVT_VECTOR_ON_FLASH, ARM_NPU, XOM_NPU_PROTECT
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\CMSIS\DSP\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\inc\npu;..\codegen\host\include;..\runtime\include;..\microtvm\ethosu\include;..\..\..\..\Library\CMSIS\NN\Include;..\;..\NPU\include;..\Pattern\include
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1.scf
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Driver
    ../../../../Library/StdDriver/src/: uart.c retarget.c clk.c sys.c gpio.c fmc.c
  group Lib
    ../../../../Library/CMSIS/Lib/Keil/: cmsis_dsp.lib cmsis_nn.lib
  group ethosu
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group User
    ../: BoardInit.cpp main.cpp TVMPlatform.c
  group runtime
    ../runtime/src/runtime/crt/common/: crt_backend_api.c crt_runtime_api.c func_registry.c ndarray.c
    ../runtime/src/runtime/crt/memory/: stack_allocator.c
  group codegen
    ../codegen/host/src/: default_lib0.c default_lib1.c default_lib3.c default_lib2.c
  group microtvm
    ../microtvm/ethosu/src/: tvm_ethosu_runtime.c
  group NPU
    ../NPU/: ethosu_cpu_cache.c ethosu_npu_init.c
  group Pattern
    ../Pattern/: InputFiles.cpp man_in_red_jacket.cpp st_paul_s_cathedral.cpp
