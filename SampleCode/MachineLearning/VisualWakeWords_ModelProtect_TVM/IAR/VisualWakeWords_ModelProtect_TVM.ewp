# IAR project VisualWakeWords_ModelProtect_TVM.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NVT_VECTOR_ON_FLASH; ARM_NPU; XOM_NPU_PROTECT
  ICCARM.CCDiagSuppress: Pe1097, Pe188, Pe301, Pe546, Pe550
  ICCARM.IExtraOptions: --diag_suppress Pe550 --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\CMSIS\DSP\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\StdDriver\inc\npu; ..\Device\include; ..\NPU\include; ..\codegen\host\include; ..\runtime\include; ..\microtvm\ethosu\include; ..\..\..\..\Library\CMSIS\NN\Include; ..; ..\Pattern\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: VisualWakeWords_ModelProtect_TVM.srec
  ILINK.IlinkOutputFile: VisualWakeWords_ModelProtect_TVM.out
  ILINK.IlinkIcfFile: M55M1.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group codegen
    ../codegen/host/src/: default_lib0.c default_lib1.c default_lib2.c default_lib3.c
  group Driver
    ../../../../Library/StdDriver/src/: clk.c fmc.c gpio.c retarget.c sys.c uart.c
  group ethosu
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group Lib
    ../../../../Library/CMSIS/Lib/IAR/: CMSIS_DSP.a CMSIS_NN.a
  group microtvm
    ../microtvm/ethosu/src/: tvm_ethosu_runtime.c
  group NPU
    ../NPU/: ethosu_cpu_cache.c ethosu_npu_init.c
  group Pattern
    ../Pattern/: InputFiles.cpp man_in_red_jacket.cpp st_paul_s_cathedral.cpp
  group runtime
    ../runtime/src/runtime/crt/common/: crt_backend_api.c crt_runtime_api.c func_registry.c ndarray.c
    ../runtime/src/runtime/crt/memory/: stack_allocator.c
  group User
    ../: BoardInit.cpp main.cpp TVMPlatform.c
