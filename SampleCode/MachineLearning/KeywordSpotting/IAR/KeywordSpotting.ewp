# IAR project KeywordSpotting.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: MODEL_DS_CNN; NVT_VECTOR_ON_FLASH; TF_LITE_STATIC_MEMORY; ARM_MATH_DSP; ARM_NPU; ACTIVATION_BUF_SZ=0x00040000
  ICCARM.CCDiagSuppress: Pe550, Pe997, Pe111, Pa082
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\CMSIS\DSP\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\StdDriver\inc\npu; ..\..\..\..\ThirdParty\openmv\omv\imlib; ..\..\..\..\ThirdParty\openmv\omv\alloc; ..\..\..\..\ThirdParty\openmv\omv\common; ..\..\..\..\ThirdParty\openmv\omv\Lib; ..\..\..\..\ThirdParty\tflite_micro; ..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-flatbuffers-src\include; ..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\api\common\include; ..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\log\include; ..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\math\include; ..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\main\include; ..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\profiler\include; ..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\api\use_case\kws\include; ..\Device\include; ..\Model\include; ..\NPU\include; ..\Pattern\include; ..\ProfilerCounter\include; ..\UAC; ..; ..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-gemlowp-src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: KeywordSpotting.srec
  ILINK.IlinkOutputFile: KeywordSpotting.out
  ILINK.IlinkIcfFile: M55M1.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Application
    ../: BoardInit.cpp main.cpp
  group ArmMLApi
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/application/api/common/source/: Classifier.cc Mfcc.cc Model.cc TensorFlowLiteMicro.cc
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/application/api/use_case/kws/src/: KwsProcessing.cc
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/math/: PlatformMath.cc
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/profiler/: Profiler.cc
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Device
    ../Device/DMICRecord/: DMICRecord.c
  group Driver
    ../../../../Library/StdDriver/src/: clk.c dmic.c gpio.c hsusbd.c lppdma.c pmc.c retarget.c sys.c uart.c
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group Lib
    ../../../../Library/CMSIS/Lib/IAR/: CMSIS_DSP.a CMSIS_NN.a
    ../../../../ThirdParty/tflite_micro/Lib/: tflu.a
  group Model
    ../Model/: ds_cnn_m_quantized_vela_H256.tflite.cpp kws_micronet_m_vela_H256.tflite.cpp KwsModel.cpp Labels.cpp
  group NPU
    ../NPU/: ethosu_cpu_cache.c ethosu_npu_init.c ethosu_profiler.c
  group Pattern
    ../Pattern/: down.cpp InputFiles.cpp right_left_up.cpp yes.cpp yes_no_go_stop.cpp
  group ProfilerCounter
    ../ProfilerCounter/: pmu_counter.c
  group UAC
    ../UAC/: descriptors.c usbd_audio.c
