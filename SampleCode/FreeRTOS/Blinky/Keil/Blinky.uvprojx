# Keil uVision project Blinky.uvprojx, settings and files
target Blinky (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.2
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: Blinky
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\release\@L.bin"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SYSTEM_CORE_CLOCK=220000000, NVT_VECTOR_ON_FLASH
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM55_NTZ\non_secure;..\..\Blinky
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1.scf
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Libraries
    ../../../../Library/StdDriver/src/: retarget.c uart.c clk.c sys.c gpio.c
  group User
    ../: main.c main-blinky.c main-full.c Reg_Test.c ParTest.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_3.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM55_NTZ/non_secure/: port.c portasm.c
  group CommonDemo
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: dynamic.c recmutex.c blocktim.c countsem.c QueueSet.c QueueOverwrite.c
