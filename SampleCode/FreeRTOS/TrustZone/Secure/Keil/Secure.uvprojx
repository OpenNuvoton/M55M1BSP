# Keil uVision project Secure.uvprojx, settings and files
target Secure (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.2
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: Secure
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\release\@L.bin"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: NVT_VECTOR_ON_FLASH
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\..\Library\StdDriver\inc;..\..;..\..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM55\secure
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\Secure.scf
  link misc: --import-cmse-lib-out ..\..\CMSELib\nsclib_keil.o
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c gpio.c fmc.c
    ../../../../../Library/StdDriver/src/scu/: mpc_sie_drv.c
  group User
    ../../: partition_M55M1.h
    ../: main_s.c
  group NSCFunctions
    ../../tz_demo/: nsc_functions.c
  group SecureContext
    ../../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM55/secure/: secure_context.c secure_context_port.c
  group SecureInit
    ../../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM55/secure/: secure_init.c
  group SecureHeap
    ../../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM55/secure/: secure_heap.c
