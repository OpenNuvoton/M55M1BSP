# IAR project NonSecure.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NVT_CMSE_NON_SECURE; NVT_VECTOR_ON_FLASH; DEBUG_PORT=UART1_NS; NVT_DBG_UART_OFF; SYSTEM_CORE_CLOCK=22000000
  ICCARM.IExtraOptions: --diag_suppress Pe550 --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\..\Library\StdDriver\inc; ..\..\..\..\..\ThirdParty\FreeRTOS\Source\include; ..\..\tz_demo; ..\..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..; ..\..\..\..\..\ThirdParty\FreeRTOS\Source\portable\IAR\ARM_CM55\non_secure; ..\..\..\..\..\ThirdParty\FreeRTOS\Source\portable\IAR\ARM_CM55\secure
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..
  OBJCOPY.OOCOutputFile: NonSecure.srec
  ILINK.IlinkOutputFile: NonSecure.out
  ILINK.IlinkIcfFile: M55M1_ns.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSELib
    ../../CMSELib/: nsclib_iar.o
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Demos
    ../../tz_demo/: tz_demo.c
  group Driver
    ../../../../../Library/StdDriver/src/: gpio.c retarget.c
  group FreeRTOS
    ../../../../../ThirdParty/FreeRTOS/Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_3.c
    ../../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM55/non_secure/: port.c portasm.s
  group User
    ../: main_ns.c
