# Keil uVision project NuBL2.uvprojx, settings and files
target NuBL2_DirectBoot (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: NuBL2_DirectBoot
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: DEBUG_PORT=UART0_NS, NUMAKER_BOARD, x__DISABLE_MSG__
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\OTA;..\ESP;..\..\ESP8266Lib;..\..\..\..\..\ThirdParty\FatFs\source;..
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\NuBL2.scf
  link misc: --import-cmse-lib-out ..\lib\nsclib_NuBL2.o --predefine="-DSIGNED_HDR_SIZE=0x0"
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c clk.c gpio.c uart.c fmc.c pmc.c sys.c ks.c crypto.c crc.c rng.c
    ../../../../../Library/StdDriver/src/scu/: mpc_sie_drv.c
  group User
    ../: partition_M55M1.h VerifyNuBL3x.c NuBL2_Lib.c main.c NuBL_crypto.c
  group ESP
    ../../ESP8266Lib/: buffer.c esp8266.c
    ../ESP/: esp8266_ll.c
  group OTA
    ../OTA/: ota.c ota_api.c ota_transfer.c CommandHandler.c
target NuBL2_SecureBoot (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: as above
  output: NuBL2_SecureBoot
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: python ..\..\FwSign.py ".\Objects\@L.bin" ..\UNSAFE_DEV_ONLY_KEY\ECC-P256.pem
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: DEBUG_PORT=UART0_NS, NUMAKER_BOARD, __DISABLE_MSG__
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\OTA;..\ESP;..\..\ESP8266Lib;..\..\..\..\..\ThirdParty\FatFs\source;..\..\common\inc;..
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\NuBL2.scf
  link misc: --import-cmse-lib-out ..\lib\nsclib_NuBL2.o
