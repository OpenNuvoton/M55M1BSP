# IAR project NuBL2.ewp, settings and files
configuration DirectBoot (ARM)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG; DEBUG_PORT=UART0_NS
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\..\Library\StdDriver\inc; ..\pmc100; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NuBL2.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: SIGNED_HDR_SIZE=0x0
  ILINK.IlinkIcfFile: NuBL2.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration SecureBoot (ARM)
  as the first configuration, except:
  ILINK.IlinkConfigDefines: SIGNED_HDR_SIZE=0x400
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Library
    ../../../../../Library/StdDriver/src/: clk.c crypto.c fmc.c gpio.c ks.c pmc.c retarget.c sys.c uart.c
    ../../../../../Library/StdDriver/src/scu/: mpc_sie_drv.c
  group User
    ../: active_sc.c main.c partition_M55M1.h VerifyNuBL3x.c
    ../pmc100/: pmc100_mem_config.c
