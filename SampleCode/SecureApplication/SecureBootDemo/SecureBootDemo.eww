<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$\NuBL2\IAR\NuBL2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\NuBL32\IAR\NuBL32.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\NuBL33\IAR\NuBL33.ewp</path>
    </project>


  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>NuBL2</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>NuBL32</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>NuBL33</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


