<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\NuBL2\IAR\NuBL2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\NuBL32\IAR\NuBL32.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\NuBL33\IAR\NuBL33.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
        </batchDefinition>
    </batchBuild>
</workspace>
