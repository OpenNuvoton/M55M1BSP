# IAR project NuBL2.ewp, settings and files
configuration DirectBoot (ARM)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG; DEBUG_PORT=UART0_NS; __DISABLE_MSG__
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\..\Library\StdDriver\inc; ..\..\..\..\..\ThirdParty\FatFs\source; ..\OTA; ..\ESP; ..\..\ESP8266Lib; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NuBL2.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: SIGNED_HDR_SIZE=0x0
  ILINK.IlinkIcfFile: $PROJ_FNAME$.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration SecureBoot (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; DEBUG_PORT=UART0_NS; NUMAKER_BOARD; __DISABLE_MSG__
  ILINK.IlinkConfigDefines: SIGNED_HDR_SIZE=0x400
  ILINK.IlinkIcfFile: NuBL2.icf
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group ESP
    ../../ESP8266Lib/: buffer.c esp8266.c
    ../ESP/: esp8266_ll.c
  group Library
    ../../../../../Library/StdDriver/src/: clk.c crc.c crypto.c fmc.c gpio.c ks.c otfc.c pmc.c retarget.c rng.c spim.c sys.c uart.c
    ../../../../../Library/StdDriver/src/scu/: mpc_sie_drv.c
  group OTA
    ../OTA/: CommandHandler.c ota.c ota_api.c ota_transfer.c
  group User
    ../: main.c NuBL2_Lib.c NuBL_crypto.c partition_M55M1.h SPIFlashInit.c VerifyNuBL3x.c
