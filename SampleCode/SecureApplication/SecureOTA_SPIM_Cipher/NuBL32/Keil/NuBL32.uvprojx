# Keil uVision project NuBL32.uvprojx, settings and files
target NuBL32_v1 (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE IROM3(0x0F100000,0x00002000)
  output: NuBL32_v1
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: python ..\..\FwSign.py ".\Objects\@L.bin" ..\UNSAFE_DEV_ONLY_KEY\ECC-P256.pem 0
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: DEBUG_PORT=UART0_NS
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: ..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\NuBL32.scf
  link misc: --import-cmse-lib-out ..\lib\nsclib_NuBL32.o
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c clk.c gpio.c uart.c fmc.c pmc.c sys.c ks.c crypto.c
    ../../../../../Library/StdDriver/src/scu/: mpc_sie_drv.c
  group User
    ../: main.c partition_M55M1.h
target NuBL32_v2 (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: as above
  output: NuBL32_v2
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: python ..\..\FwSign.py ".\Objects\@L.bin" ..\UNSAFE_DEV_ONLY_KEY\ECC-P256.pem 1
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: DEBUG_PORT=UART0_NS, __NEW_VER__
  c misc: -Wconditional-uninitialized -mno-unaligned-access
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\NuBL32.scf
  link misc: --import-cmse-lib-out ..\lib\nsclib_NuBL32.o
