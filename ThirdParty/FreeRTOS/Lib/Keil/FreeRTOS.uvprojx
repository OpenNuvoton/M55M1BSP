# Keil uVision project FreeRTOS.uvprojx, settings and files
target Release (6190000::V6.19::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: FreeRTOS (library)
  AfterMake: xcopy /Y .\Objects\FreeRTOS.lib ..\
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: SYSTEM_CORE_CLOCK=220000000
  c misc: -mno-unaligned-access -Wconditional-uninitialized
  c include: ..\..\Source\include;..\..\Source\portable\GCC\ARM_CM55_NTZ\non_secure;..\..\Lib
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Source
    ../../Source/: tasks.c list.c queue.c croutine.c event_groups.c stream_buffer.c timers.c
    ../../Source/portable/MemMang/: heap_3.c
    ../../Source/portable/GCC/ARM_CM55_NTZ/non_secure/: port.c portasm.c
