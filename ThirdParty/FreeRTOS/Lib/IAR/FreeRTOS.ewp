# IAR project FreeRTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: SYSTEM_CORE_CLOCK=220000000
  ICCARM.IExtraOptions: --diag_suppress Pe550; --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\Source\include; ..; ..\..\Source\portable\IAR\ARM_CM55_NTZ\non_secure
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: tflu.out
  group Source
    ../../Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Source/portable/MemMang/: heap_3.c
    ../../Source/portable/IAR/ARM_CM55_NTZ/non_secure/: port.c portasm.s
