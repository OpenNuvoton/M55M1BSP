# IAR project omv.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.IExtraOptions: --diag_suppress Pe550 --no_unaligned_access; --diag_suppress Pe177
  ICCARM.CCIncludePath2: ..\..\imlib; ..\..\alloc; ..\..\common; ..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\..\Library\CMSIS\DSP\Include; ..\..\..\..\..\Library\CMSIS\NN\Include; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: tflu.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.IExtraOptions: --no_unaligned_access
  group alloc
    ../../alloc/: dma_alloc.c fb_alloc.c umm_malloc.c xalloc.c
  group common
    ../../common/: array.c mutex.c
  group imlib
    ../../imlib/: agast.c apriltag.c bayer.c binary.c blob.c bmp.c clahe.c collections.c dmtx.c draw.c edge.c eye.c fast.c fft.c filter.c fmath.c font.c framebuffer.c fsort.c gif.c haar.c hog.c hough.c imlib.c imlib_nvt.c integral.c integral_mw.c jpeg.c jpegd.c kmeans.c lab_tab.c lbp.c line.c lodepng.c lsd.c mathop.c mjpeg.c orb.c phasecorrelation.c png.c point.c pool.c ppm.c qrcode.c qsort.c rainbow_tab.c rectangle.c selective_search.c sincos_tab.c stats.c stereo.c template.c xyz_tab.c yuv.c zbar.c
