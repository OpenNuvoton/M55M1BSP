# Keil uVision project omv.uvprojx, settings and files
target Release (6240000::V6.24::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: omv (library)
  AfterMake: xcopy /Y .\Objects\omv.lib ..\
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c misc: -Wno-shift-count-overflow -Wno-absolute-value -Wno-shift-negative-value -mno-unaligned-access -Wconditional-uninitialized
  c include: ..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\Library\CMSIS\NN\Include;..\..\..\..\..\Library\CMSIS\DSP\Include;..\..\imlib;..\..\alloc;..\..\common;..\..\Lib
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group imlib
    ../../imlib/: agast.c apriltag.c bayer.c binary.c blob.c bmp.c clahe.c collections.c dmtx.c draw.c edge.c eye.c fast.c fft.c filter.c fmath.c font.c framebuffer.c fsort.c gif.c haar.c hog.c hough.c imlib.c integral.c integral_mw.c jpeg.c jpegd.c kmeans.c lab_tab.c lbp.c line.c lodepng.c lsd.c mathop.c mjpeg.c orb.c phasecorrelation.c png.c point.c pool.c ppm.c qrcode.c qsort.c rainbow_tab.c rectangle.c selective_search.c sincos_tab.c stats.c stereo.c template.c xyz_tab.c yuv.c zbar.c imlib_nvt.c
  group alloc
    ../../alloc/: dma_alloc.c fb_alloc.c umm_malloc.c unaligned_memcpy.c xalloc.c
  group common
    ../../common/: array.c mutex.c
